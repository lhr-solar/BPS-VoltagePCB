# Repository lhr-solar/BPS-VoltagePCB

## KiCad design BPS-Minion.kicad_pcb

Board: 2 copper layers, 160.0 x 63.0 mm, 224 parts (110 on the bottom side), 159 nets.

Parts:
C1, C61, C62: 10uF; C_0805_2012Metric
C2, C3, C7, C8, C10, C13, C14, C15, C18, C19, C20, C23, C24: 1uF; C_0805_2012Metric
C4, C9: 4.7uF; C_0805_2012Metric
C5, C11: 0.47uF; C_0805_2012Metric
C6, C12: 100pF; C_0805_2012Metric
C16, C17, C21, C22: 47nF; C_0805_2012Metric
C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60: 220nF; C_0805_2012Metric
D1: Green; LED_0805_2012Metric
D2, D3: 1N4448W; D_SOD-123
J1, J12: TEMPSPIANALYZER; PinHeader_1x04_P2.54mm_Vertical
J2: BMS1OTP; PinHeader_1x04_P2.54mm_Vertical
J3: BMS2OTP; PinHeader_1x04_P2.54mm_Vertical
J4, J5: Conn_01x24_Female; B24B-PADSS-F
J6, J7, J8, J9, J10, J11: TopConn; Molex_Micro-Fit_3.0_43650-0600_1x06_P3.00mm_Horizontal
J13: CAN_IN; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical
J14: CAN_OUT; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical
R1, R13: 1k; R_0805_2012Metric
R3, R10: 220; R_0805_2012Metric
R4, R5, R6, R7, R8, R11, R12, R14, R15, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50: 10k; R_0805_2012Metric
R9, R16: 100; R_0805_2012Metric
R33, R34, R51, R52: 4.7k; R_0805_2012Metric
R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88: 20; R_0805_2012Metric
R89, R90, R91, R94: 100k; R_0805_2012Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36: TestPoint_2Pole; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
TP37, TP38, TP39, TP40, TP45, TP46: TestPoint; TestPoint_Keystone_5005-5009_Compact
U1: PeripheralSOM
U2, U5: BQ7695201PFBR; TQFP-48_7x7mm_P0.5mm
U3, U6: ISO1640BDR; SOIC-8_3.9x4.9mm_P1.27mm
U4, U7: EL3H7; SOP-4_4.4x2.6mm_P1.27mm
U8, U10: LM321; SOT-23-5
U9, U11: ADS7953SBDBT; TSSOP-38_4.4x9.7mm_P0.5mm
U12: MIC5317-2.5xM5; SOT-23-5

Connections:
+2V5: C2.1, C61.2, C62.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, TP45.1, U9.4 (REFP), U11.4 (REFP), U12.5 (VOUT)
+3.3V: C3.2, C10.2, C15.2, C20.2, R1.2, R89.1, R90.1, U1.2 (+3.3V), U1.9 (+3.3V), U3.1 (VCC1), U6.1 (VCC1), U9.36 (VBD+), U11.36 (VBD+)
+12V: J13.1, J14.1, U1.22 (+12V_In)
/BMS/BMS1BAT: C5.2, C6.2, C8.2, J2.4, R9.1, TP38.1, U2.47 (BAT)
/BMS/BMS1Reg1: C7.1, R4.1, R7.1, U2.35 (REG1), U3.8 (VCC2), U4.4
/BMS/BMS1Reset: R8.2, U2.33 (RST_SHUT), U4.3
/BMS/BMS1SCL: J2.2, R7.2, U2.26 (SCL), U3.6 (SCL2)
/BMS/BMS1SDA: J2.3, R4.2, U2.27 (SDA), U3.7 (SDA2)
/BMS/BMS2BAT: C11.2, C12.2, C13.2, J3.4, R16.1, TP37.1, U5.47 (BAT)
/BMS/BMS2Reg1: C14.1, R14.1, R15.1, U5.35 (REG1), U6.8 (VCC2), U7.4
/BMS/BMS2Reset: R13.2, U5.33 (RST_SHUT), U7.3
/BMS/BMS2SCL: J3.2, R15.2, U5.26 (SCL), U6.6 (SCL2)
/BMS/BMS2SDA: J3.3, R14.2, U5.27 (SDA), U6.7 (SDA2)
/BMS/BatteryConnector6/cell4+: C58.1, C59.2, R86.2, TP34.2, TP35.1
/BMS/BatteryConnector6/cell5+: C59.1, C60.2, R87.2, TP35.2, TP36.1
/BMS/BatteryConnector6/cell6+: C60.1, R88.2, TP36.2
/BMS/cell1: C26.1, C27.2, R54.2, TP2.2, TP3.1, U2.15 (VC1)
/BMS/cell2: C27.1, C28.2, R55.2, TP3.2, TP4.1, U2.14 (VC2)
/BMS/cell3: C28.1, C29.2, R56.2, TP4.2, TP5.1, U2.13 (VC3)
/BMS/cell4: C29.1, C30.2, R57.2, TP5.2, TP6.1, U2.12 (VC4)
/BMS/cell5: C30.1, C31.2, R58.2, TP6.2, TP7.1, U2.11 (VC5)
/BMS/cell6: C31.1, C32.2, R59.2, TP7.2, TP8.1, U2.10 (VC6)
/BMS/cell7: C32.1, C33.2, R60.2, TP8.2, TP9.1, U2.9 (VC7)
/BMS/cell8: C33.1, C34.2, R61.2, TP9.2, TP10.1, U2.8 (VC8)
/BMS/cell9: C34.1, C35.2, R62.2, TP10.2, TP11.1, U2.7 (VC9)
/BMS/cell10: C35.1, C36.2, R63.2, TP11.2, TP12.1, U2.6 (VC10)
/BMS/cell11: C36.1, C37.2, R64.2, TP12.2, TP13.1, U2.5 (VC11)
/BMS/cell12: C37.1, C38.2, R65.2, TP13.2, TP14.1, U2.4 (VC12)
/BMS/cell13: C38.1, C39.2, R66.2, TP14.2, TP15.1, U2.3 (VC13)
/BMS/cell14: C39.1, C40.2, R67.2, TP15.2, TP16.1, U2.2 (VC14)
/BMS/cell15: C40.1, C41.2, R68.2, TP16.2, TP17.1, U2.1 (VC15)
/BMS/cell17: C42.1, C43.2, R70.2, TP18.2, TP19.1, U5.15 (VC1)
/BMS/cell18: C43.1, C44.2, R71.2, TP19.2, TP20.1, U5.14 (VC2)
/BMS/cell19: C44.1, C45.2, R72.2, TP20.2, TP21.1, U5.13 (VC3)
/BMS/cell20: C45.1, C46.2, R73.2, TP21.2, TP22.1, U5.12 (VC4)
/BMS/cell21: C46.1, C47.2, R74.2, TP22.2, TP23.1, U5.11 (VC5)
/BMS/cell22: C47.1, C48.2, R75.2, TP23.2, TP24.1, U5.10 (VC6)
/BMS/cell23: C48.1, C49.2, R76.2, TP24.2, TP25.1, U5.9 (VC7)
/BMS/cell24: C49.1, C50.2, R77.2, TP25.2, TP26.1, U5.8 (VC8)
/BMS/cell25: C50.1, C51.2, R78.2, TP26.2, TP27.1, U5.7 (VC9)
/BMS/cell26: C51.1, C52.2, R79.2, TP27.2, TP28.1, U5.6 (VC10)
/BMS/cell27: C52.1, C53.2, R80.2, TP28.2, TP29.1, U5.5 (VC11)
/BMS/cell28: C53.1, C54.2, R81.2, TP29.2, TP30.1, U5.4 (VC12)
/BMS/cell29: C54.1, C55.2, R82.2, TP30.2, TP31.1, U5.3 (VC13)
/BMS/cell30: C55.1, C56.2, R83.2, TP31.2, TP32.1, U5.2 (VC14)
/BMS/cell31: C56.1, C57.2, R84.2, TP32.2, TP33.1, U5.1 (VC15)
/BMS/cell32: C57.1, C58.2, D3.2 (A), R11.1, R12.1, R85.2, TP33.2, TP34.1, U5.48 (VC16)
/CAN_H: J13.3, J14.3, U1.23 (CAN_H)
/CAN_L: J13.4, J14.4, U1.21 (CAN_L)
/I2C1_SCL: U1.14 (I2C1_SCL), U3.3 (SCL1), U6.3 (SCL1)
/I2C1_SDA: U1.16 (I2C1_SDA), U3.2 (SDA1), U6.2 (SDA1)
/PA2: R3.1, R10.1, U1.20 (PA1(ADC))
/SPI1_MISO: J1.2, U1.17 (SPI1_MOSI), U9.34 (SDO)
/SPI1_MOSI: J1.3, U1.13 (SPI1_SCK), U9.33 (SDI)
/SPI1_NSS: U1.19 (SPI1_NSS), U9.31 (*CS)
/SPI1_SCK: J1.4, U1.15 (SPI1_MISO), U9.32 (SCLK)
/SPI2_MISO: J12.2, U1.3 (SPI2_MISO), U11.34 (SDO)
/SPI2_MOSI: J12.3, U1.1 (SPI2_MOSI), U11.33 (SDI)
/SPI2_NSS: U1.7 (SPI2_NSS), U11.31 (*CS)
/SPI2_SCK: J12.4, U1.5 (SPI2_SCK), U11.32 (SCLK)
/Temperature1/ADCIN: U10.3 (-), U10.4, U11.8 (AINP)
/Temperature1/MUXOUT: R51.2, U11.7 (MXO)
/Temperature1/temp1: J5.16, R35.1, U11.28 (CH0)
/Temperature1/temp2: J5.18, R37.1, U11.27 (CH1)
/Temperature1/temp3: J5.19, R39.1, U11.26 (CH2)
/Temperature1/temp4: J5.21, R41.1, U11.25 (CH3)
/Temperature1/temp5: J5.23, R43.1, U11.24 (CH4)
/Temperature1/temp6: J5.24, R45.1, U11.23 (CH5)
/Temperature1/temp7: J5.22, R47.1, U11.22 (CH6)
/Temperature1/temp8: J5.20, R49.1, U11.21 (CH7)
/Temperature1/temp9: J5.17, R36.1, U11.18 (CH8)
/Temperature1/temp10: J5.15, R38.1, U11.17 (CH9)
/Temperature1/temp11: J5.11, R40.1, U11.16 (CH10)
/Temperature1/temp12: J5.9, R42.1, U11.15 (CH11)
/Temperature1/temp13: J5.7, R44.1, U11.14 (CH12)
/Temperature1/temp14: J5.5, R46.1, U11.13 (CH13)
/Temperature1/temp15: J5.3, R48.1, U11.12 (CH14)
/Temperature1/temp16: J5.4, R50.1, U11.11 (CH15)
/Temperature/ADCIN: U8.3 (-), U8.4, U9.8 (AINP)
/Temperature/MUXOUT: R33.2, U9.7 (MXO)
/Temperature/temp1: J4.16, R17.1, U9.28 (CH0)
/Temperature/temp2: J4.18, R19.1, U9.27 (CH1)
/Temperature/temp3: J4.19, R21.1, U9.26 (CH2)
/Temperature/temp4: J4.21, R23.1, U9.25 (CH3)
/Temperature/temp5: J4.23, R25.1, U9.24 (CH4)
/Temperature/temp6: J4.24, R27.1, U9.23 (CH5)
/Temperature/temp7: J4.22, R29.1, U9.22 (CH6)
/Temperature/temp8: J4.20, R31.1, U9.21 (CH7)
/Temperature/temp9: J4.17, R18.1, U9.18 (CH8)
/Temperature/temp10: J4.15, R20.1, U9.17 (CH9)
/Temperature/temp11: J4.11, R22.1, U9.16 (CH10)
/Temperature/temp12: J4.9, R24.1, U9.15 (CH11)
/Temperature/temp13: J4.7, R26.1, U9.14 (CH12)
/Temperature/temp14: J4.5, R28.1, U9.13 (CH13)
/Temperature/temp15: J4.3, R30.1, U9.12 (CH14)
/Temperature/temp16: J4.4, R32.1, U9.11 (CH15)
GND: C3.1, C10.1, C15.1, C20.1, D1.1 (K), J1.1, J12.1, R91.2, R94.2, U1.4 (GND), U1.11 (GND), U3.4 (GND1), U4.2, U6.4 (GND1), U7.2, U9.35 (BDGND), U11.35 (BDGND)
GND1: C4.1, C6.1, C7.2, C8.1, C25.1, C25.2, C26.2, J2.1, R8.1, R53.2, TP1.1, TP1.2, TP2.1, TP39.1, U2.16 (VC0), U2.17 (VSS), U2.18 (SRP), U2.20 (SRN), U2.36 (REGIN), U2.37 (BREG), U3.5 (GND2)
GND2: C9.1, C12.1, C13.1, C14.2, C41.1, C42.2, D2.2 (A), J3.1, R5.1, R6.1, R13.1, R69.2, TP17.2, TP18.1, TP40.1, U2.48 (VC16), U5.16 (VC0), U5.17 (VSS), U5.18 (SRP), U5.20 (SRN), U5.36 (REGIN), U5.37 (BREG), U6.5 (GND2)
GNDA: C1.1, C2.2, C16.1, C17.1, C18.2, C19.2, C21.1, C22.1, C23.2, C24.2, C61.1, C62.1, J4.1, J4.2, J4.13, J4.14, J5.1, J5.2, J5.13, J5.14, TP46.1, U1.12 (GNDA), U8.2 (V-), U9.3 (REFM), U9.6 (AGND), U9.9 (AINM), U9.10 (AGND), U9.19 (AGND), U9.20 (AGND), U9.30 (AGND), U10.2 (V-), U11.3 (REFM), U11.6 (AGND), U11.9 (AINM), U11.10 (AGND), U11.19 (AGND), U11.20 (AGND), U11.30 (AGND), U12.2 (GND)
GNDPWR: J13.2, J14.2, U1.24 (GNDPWR)
unnamed: C16.2, R33.1, R34.2
unnamed: C21.2, R51.1, R52.2
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), R9.2
unnamed: D3.1 (K), R16.2
unnamed: J6.1, R53.1
unnamed: J6.2, R54.1
unnamed: J6.3, R55.1
unnamed: J6.4, R56.1
unnamed: J6.5, R57.1
unnamed: J6.6, R58.1
unnamed: J7.1, R59.1
unnamed: J7.2, R60.1
unnamed: J7.3, R61.1
unnamed: J7.4, R62.1
unnamed: J7.5, R63.1
unnamed: J7.6, R64.1
unnamed: J8.1, R65.1
unnamed: J8.2, R66.1
unnamed: J8.3, R67.1
unnamed: J8.4, R68.1
unnamed: J8.5, R69.1
unnamed: J8.6, R70.1
unnamed: J9.1, R71.1
unnamed: J9.2, R72.1
unnamed: J9.3, R73.1
unnamed: J9.4, R74.1
unnamed: J9.5, R75.1
unnamed: J9.6, R76.1
unnamed: J10.1, R77.1
unnamed: J10.2, R78.1
unnamed: J10.3, R79.1
unnamed: J10.4, R80.1
unnamed: J10.5, R81.1
unnamed: J10.6, R82.1
unnamed: J11.1, R83.1
unnamed: J11.2, R84.1
unnamed: J11.3, R85.1
unnamed: J11.4, R86.1
unnamed: J11.5, R87.1
unnamed: J11.6, R88.1
unnamed: R3.2, U4.1
unnamed: R10.2, U7.1
unnamed: C5.1, U2.46 (CP1)
unnamed: R6.2, U2.41 (LD)
unnamed: R5.2, U2.42 (PACK)
unnamed: C4.2, U2.24 (REG18)
unnamed: C11.1, U5.46 (CP1)
unnamed: R12.2, U5.41 (LD)
unnamed: R11.2, U5.42 (PACK)
unnamed: C9.2, U5.24 (REG18)
unnamed: C17.2, R34.1, U8.1 (+)
unnamed: R91.1, U9.1 (GPIO2)
unnamed: R89.2, U9.2 (GPIO3)
unnamed: C22.2, R52.1, U10.1 (+)
unnamed: R94.1, U11.1 (GPIO2)
unnamed: R90.2, U11.2 (GPIO3)
VDDA: C1.2, C18.1, C19.1, C23.1, C24.1, U1.10 (VDDA(3.3V)), U8.5 (V+), U9.5 (VA+), U9.29 (VA+), U10.5 (V+), U11.5 (VA+), U11.29 (VA+), U12.1 (VIN), U12.3 (EN)

## Commit log

2024-10-13 moved new minion PCB over
2024-10-14 BOOM
2024-10-14 grrrrr
2024-10-14 boom 2 electric boomgaloo
